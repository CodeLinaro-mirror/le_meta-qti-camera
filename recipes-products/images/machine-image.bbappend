include ${BASEMACHINE}/${BASEMACHINE}-camera-image.inc
