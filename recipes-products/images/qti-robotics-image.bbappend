# Camera packages
include qrb5165-rb5/qrb5165-rb5-camera-image.inc
